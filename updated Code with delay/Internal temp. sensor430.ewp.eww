<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Internal temp. sensor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


